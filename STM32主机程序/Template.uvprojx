# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\input;.\APP\iic;.\APP\tftlcd;.\APP\dht11;.\APP\oled;.\APP\printf;.\APP\BH1750;.\APP\CO2_usart;.\APP\esp8266\ESP8266_drive;.\APP\esp8266\ESP8266_Public;.\APP\esp8266\STA_TCPClent_Test;.\APP\beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/oled/: oled.c
    ./APP/input/: input.c
    ./APP/printf/: printf.c
    ./APP/dht11/: dht11.c
    ./APP/BH1750/: BH1750.c
    ./APP/iic/: iic.c
    ./APP/CO2_usart/: CO2.c
    ./APP/esp8266/ESP8266_drive/: esp8266_drive.c
    ./APP/esp8266/ESP8266_Public/: esp8266_public.c
    ./APP/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
    ./APP/beep/: beep.c
  group Public
    ./Public/: system.c SysTick.c
