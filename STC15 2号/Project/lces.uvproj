# Keil uVision project lces.uvproj, settings and files
target Project (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lces +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Library
  group System
    ./: STARTUP.A51
  group User
    ../User/: delay.c main.c uart.c dht11.c oled12864.c
